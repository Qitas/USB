# Keil uVision project HID.uvprojx, settings and files
target MCBSTM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hid
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Initialisation
    ./: STM32_Init.c
  group Configuration
    ./: usbcfg.h
  group Source Code
    ./: LCD_4bit.c demo.c usbhw.c usbuser.c usbdesc.c usbcore.c hiduser.c
  group Documentation
    ./: Abstract.txt
